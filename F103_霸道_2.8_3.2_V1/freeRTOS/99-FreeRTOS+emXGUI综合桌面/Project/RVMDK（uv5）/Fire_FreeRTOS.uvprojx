# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,X_GUI_USE_FREERTOS,USE_STDPERIPH_DRIVER,
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\led;..\..\User\usart;..\..\User\Key;..\..\User\liuwei;..\..\User\liuwei\drv_inc;..\..\User\liuwei\spi_flash;..\..\User\liuwei\System_Drv;..\..\User\liuwei\X_GUI_Drv;..\..\..\..\..\emXGUI_Lib\inc;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\app\base;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib;..\..\User\bsp;..\..\..\..\..\emXGUI_Lib\arch;..\..\User\bsp\drv_inc;..\..\User\bsp\FATFS;..\..\User\bsp\FATFS\option;..\..\User\App\GUI_Demo;..\..\User\App\Board_App\pic_viewer;..\..\User\OwnerDraw;..\..\User\App\GUI_Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h FreeRTOSConfig.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ../../User/bsp/usart/: bsp_usart.c
    ../../User/bsp/spi_flash/: bsp_flash_spi.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/Key/: bsp_key.c
    ../../User/bsp/sdio/: bsp_sdio_sdcard.c
    ../../User/bsp/LCD/: ILI9341_16Bit.c ADS7843.c DMA_LCD.c
    ../../User/bsp/fsmc/: bsp_fsmc.c
  group FatFs
    ../../User/bsp/FATFS/: diskio.c ff.c
    ../../User/bsp/FATFS/option/: cc936.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group OEM_Face
    ../../../../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c
  group emxgui/arch
    ../../../../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c EXT_LCD_Arch.c GUI_TouchPanel.c GUI_TouchPanel_Calibration.c
    ../../../../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../../../../emXGUI_Lib/arch/Inc/: gui_drv.h gui_os_port.h
  group emxgui/resource
    ../../../../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emxgui/inc
    ../../../../../emXGUI_Lib/inc/: GUI_Font_XFT.h emXGUI_Arch.h emXGUI.h def.h Web_Color.h x_libc.h x_obj.h
  group emxgui/libs
    ../../../../../emXGUI_Lib/libs/: x_libc_MDK_M3.lib emXGUI100_MDK_M3.lib libjpeg_MDK_CM3.lib libpng_MDK_CM3.lib x_obj.cpp
  group emxgui/drv
    ../../../../../emXGUI_Lib/drv/: gui_lcd_port.c gui_startup.c gui_input_port.c gui_touch_port.c gui_font_port.c gui_mem_port.c gui_log_port.c gui_resource_port.c gui_fs_port.c gui_picture_port.c
    ../../User/: gui_drv_cfg.h
  group base_app
    ../../../../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../../../../emXGUI_Lib/app/base/: gui_desktop.c
    ../../../../../emXGUI_Lib/app/base/res_writer/: backend_res_writer.c GUI_RES_Writer_Dialog.c
  group gui_app
    ../../User/App/GUI_Demo/: GUI_DEMO_SlideWindow.c CListMenu.cpp GUI_App_Desktop.c GUI_DEMO_Graphics_Accelerator.c
    ../../User/App/Board_App/: GUI_Board_App_Desktop.c
    ../../User/App/Board_App/pic_viewer/: GUI_PicViwer_Dialog.c
    ../../User/OwnerDraw/: Widget.c
  group board_app
    ../../User/App/GUI_Demo/: GUI_DEMO_ShowWave.cpp
  group app_res
    ../../../../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group DOC
    ../../Doc/: readme.txt
